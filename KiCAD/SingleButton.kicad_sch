File: KiCAD/SingleButton.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: fix ERC/DRC violations
Parts:
- renumbered R3 to R2, SW1 to SW16
